require linux-yocto-podman.inc

KERNEL_FEATURES:append:tdx=" podman.scc"
